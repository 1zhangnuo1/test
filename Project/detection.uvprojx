# Keil uVision project detection.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: detection +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD
  c include: ..\User;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\CMSIS\Include;..\User\bsp;..\User\sysinit;..\User\bsp\inc;..\User\bsp\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ../User/: main.c include.h
  group BSP
    ../User/bsp/: stm32f10x_conf.h bsp.h bsp.c
    ../User/sysinit/: bsp_usart.c bsp_delay.c
    ../User/bsp/src/: pwm.c adc.c
    ../User/: pwm_app.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_ld.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Doc
    ./: 讲解文件.txt
